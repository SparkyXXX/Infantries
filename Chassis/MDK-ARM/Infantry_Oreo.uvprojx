# Keil uVision project Infantry_Oreo.uvprojx, settings and files
target Infantry_Oreo (6190000::V6.19::ARMCLANG)
  device: STM32G473CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Infantry_Oreo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32G473xx,ARM_MATH_CM4,__TARGET_FPU_VFP
  c include: ../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Core/Inc;../User/Infantry;../User/Algorithm;../User/Application;../User/Protocol;../User/Library;../User/Peripheral;../User/Utility;../User/System
  asm include: ..\Core\Inc;../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c dma.c fdcan.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_fdcan.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Infantry
    ../User/Infantry/: callback_ctrl.c task_ctrl.c config_ctrl.c
  group Application
    ../User/Application/: app_chassis.cpp app_gimbal.c app_power.c app_ui.cpp app_monitor.c
  group Protocol
    ../User/Protocol/: protocol_motor.c protocol_board.c protocol_referee.c
  group Algorithm
    ../User/Algorithm/: alg_pid.c
  group Library
    ../User/Library/: lib_math.c lib_filter.c lib_buff.c lib_crc.c lib_power_ctrl.cpp
  group Peripheral
    ../User/Peripheral/: periph_motor_can.c periph_cap.c
  group Utility
    ../User/Utility/: util_uart.c util_fdcan.c
  group System
    ../User/System/: sys_dwt.c
software components: CMSIS:CORE 5.6.0
